Commit message: cleaned up PosOriTask and PositionTask plus revamped the examples

File: examples/01-joint_control/puma.urdf (robot description, URDF)
Before this commit: robot Puma, 7 links, 6 joints
Links:
- link end-effector: mass 0.09 -> 0.39
